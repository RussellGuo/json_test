# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac5.sct
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 2.0.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
