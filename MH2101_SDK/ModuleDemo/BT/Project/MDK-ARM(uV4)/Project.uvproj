# Keil uVision project Project.uvproj, settings and files
target target (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c misc: --c99 --gnu  --enum_is_int
  c include: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\bt_driver;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/: bt42_bluetoothfunc.c main.c
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_exti.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_timer.c mhscpu_uart.c misc.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group BTdriver
    ../../bt_driver/: bt42_timer.c bt42_uart.c hw_config.c multi_timer.c bt42_hci_cmd_8200H.c
