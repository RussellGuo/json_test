# IAR project CryptTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\MHSCPU_Driver\inc; ..\..\..\..\Libraries\MHSCPU_Driver\inc\securelib; ..\..\..\..\Libraries\MHSCPU_Driver\lib; ..\..\test; ..\..\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CryptTest.hex
  ILINK.IlinkOutputFile: CryptTest.out
  ILINK.IlinkIcfFile: CryptTest.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Libraries\MHSCPU_Driver\lib\IAR_CryptLib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Crypt_lib
    ../../../../Libraries/MHSCPU_Driver/lib/: IAR_CryptLib.a
  group CRYPT_SELF_TEST
    ../../test/: aes_self_test.c client_test.c crypt_time_test.c debug.c debug.h des_self_test.c ecc_self_test.c mh_bignum_tool.c mh_bignum_tool.h rand_self_test.c rsa_self_test.c sha_self_test.c sm2_decryptencrypt_self_test.c sm2_digitalsign_self_test.c sm2_keyexchange_self_test.c sm3_self_test.c sm4_self_test.c timer.c timer.h
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/IAR/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mh_rand.c mhscpu_dma.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_timer.c mhscpu_uart.c misc.c
  group User
    ../../User/: main.c mhscpu_conf.h mhscpu_it.c mhscpu_it.h
