# Keil uVision project Project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --enum_is_int
  c include: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc\cryptlib;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\User\cryptlibTest
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group User
    ../../User/: main.c mhscpu_it.c
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_gpio.c mhscpu_timer.c mhscpu_trng.c mhscpu_dma.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group CRYPT_SELF_TEST
    ../../User/cryptlibTest/: sm3_self_test.c ecc_self_test.c des_self_test.c aes_self_test.c sm4_self_test.c sm2_self_test.c rsa_self_test.c sha_self_test.c crypt_debug.c sm1_self_test.c mh_bignum_tool.c sm9_encapdecap_self_test.c sm9_encdec_self_test.c sm9_signverify_self_test.c
  group CRYPT_LIB
    ../../../../Libraries/MHSCPU_Driver/lib/: crypt_s_lib.lib
