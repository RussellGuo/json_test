# Keil uVision project freertos.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\CMSIS_RTOS;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x100000
  link misc: --diag_suppress=L6329
  group User
    ../../User/: main.c mhunt_it.c
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_uart.c mhscpu_dma.c mhscpu_timer.c mhscpu_adc.c mhscpu_bpk.c mhscpu_crc.c mhscpu_exti.c mhscpu_rtc.c mhscpu_sensor.c mhscpu_trng.c mhscpu_dac.c mhscpu_spi.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group FREERTOS
    ../../FreeRTOS/Source/: queue.c tasks.c timers.c croutine.c event_groups.c list.c stream_buffer.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
