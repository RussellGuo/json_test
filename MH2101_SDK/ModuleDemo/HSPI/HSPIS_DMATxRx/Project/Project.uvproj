# Keil uVision project Project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20004000 size 0x40000
  group User
    ../User/: main.c
  group Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_dma.c mhscpu_gpio.c mhscpu_hspim.c mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_hspis.c
  group Startup
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
target RAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Project
  c flags: Optim=1
