# Keil uVision project Project.uvproj, settings and files
target Flash (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: I2C_EEPROM_Interrupt_Flash +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c mhscpu_it.c ring_buffer.c delay.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_dma.c mhscpu_gpio.c mhscpu_i2c.c mhscpu_timer.c mhscpu_uart.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
