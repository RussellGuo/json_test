# Keil uVision project Project.uvproj, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Keyboard_Overrun_Polling +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,QFN88_EVB_V1_1
  c include: ..\..\User;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_gpio.c mhscpu_kcu.c mhscpu_sysctrl.c mhscpu_uart.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
