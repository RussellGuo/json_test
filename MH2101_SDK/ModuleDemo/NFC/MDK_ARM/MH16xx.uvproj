# Keil uVision project MH16xx.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MH16xx +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,PACKAGE_QFN68
  c include: ..\User;..\User\16xx;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\MHSCPU_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK_ARM
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group user
    ../User/: main.c gpio.c spi.c timer.c uart.c mhscpu_it.c
  group MHSCPU_Driver
    ../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_timer.c mhscpu_uart.c mhscpu_sysctrl.c mhscpu_spi.c mhscpu_gpio.c
  group 16xx
    ../User/16xx/: iso14443_4.c iso14443a.c iso14443b.c mh523.c mifare.c rfid.c
