# Keil uVision project Project.uvprojx, settings and files
target DecodeDemo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: QRDecode +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User\inc
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group User
    ../../User/: main.c mhscpu_it.c
    ../../User/src/: uart.c beep.c DecodeDemo.c
    ../../User/inc/: ProjectConfig.h
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_gpio.c mhscpu_dcmi.c mhscpu_dma.c mhscpu_timer.c mhscpu_i2c.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group DecodeLib
    ../../../../Libraries/MHSCPU_Driver/lib/: MH2101KeilDecodeLib.lib
software components: CMSIS:CORE 5.1.2
