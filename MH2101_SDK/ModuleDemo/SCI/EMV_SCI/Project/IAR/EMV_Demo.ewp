# IAR project EMV_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\..\User; ..\..\..\..\..\Libraries\MHSCPU_Driver\inc; ..\..\..\..\..\Libraries\MHSCPU_Driver\inc\emvlib; ..\..\..\..\Libraries\MHSCPU_Driver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MH2101_EMV_Demo_IAR.hex
  ILINK.IlinkOutputFile: EMV_Demo.out
  ILINK.IlinkIcfFile: EMV_Demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Lib
    ../../../../../Libraries/MHSCPU_Driver/lib/: MH2101_EMV_IAR.a
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/IAR/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_emv_hard.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_uart.c misc.c
  group User
    ../../User/: main.c test_emv.c test_loopback.c uart.c
