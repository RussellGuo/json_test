# Keil uVision project USBDevice.uvproj, settings and files
target USBDevice (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: USBDevice +hex
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,CONFIG_MHSCPU,CONFIG_MHSCPU_MH2101,CONFIG_USB_DEVICE_MSD,CONFIG_USB_DEVICE_VCP,CONFIG_USB_DEVICE_HID,
  c misc: --c99
  c include: ..\..\APP\inc;..\..\BSP\inc;..\..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\..\Libraries\USB-ESL;..\..\..\..\..\..\Libraries\cmsis\Include
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group APP
    ../../App/inc/: App.h
    ../../App/src/: App.c
  group BSP
    ../../BSP/inc/: mhscpu_conf.h USBVendorConfig.h
    ../../BSP/src/: USBBSP.c USBMSD.c VirtualFatFS.c USBVCP.c USBHID.c
  group Driver
    ../../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_uart.c
    ../../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group Driver\USB-ESL
    ../../../../../../Libraries/USB-ESL/Target/: USBTargetMH2101.c
    ../../../../../../Libraries/USB-ESL/: USBCoreZoffy.c USBDevice.c USBInterface.c InterfaceSetup.c InterfaceMSD.c InterfaceCDC.c InterfaceSerial.c InterfaceHID.c CircularBuffer.c
