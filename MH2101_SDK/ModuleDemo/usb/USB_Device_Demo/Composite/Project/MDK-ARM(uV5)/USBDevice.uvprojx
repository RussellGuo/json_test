# Keil uVision project USBDevice.uvprojx, settings and files
target USBDevice (6180000::V6.18::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: USBDevice +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,CONFIG_MHSCPU,CONFIG_MHSCPU_MH2101,CONFIG_USB_DEVICE_MSD,CONFIG_USB_DEVICE_VCP,CONFIG_USB_DEVICE_HID,
  c include: ..\..\APP\inc;..\..\BSP\inc;..\..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\..\Libraries\USB-ESL;..\..\..\..\..\..\Libraries\cmsis\Include
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group APP
    ../../App/inc/: App.h
    ../../App/src/: App.c
  group BSP
    ../../BSP/inc/: mhscpu_conf.h USBVendorConfig.h
    ../../BSP/src/: USBBSP.c USBMSD.c VirtualFatFS.c USBVCP.c USBHID.c
  group Driver
    ../../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_uart.c
    ../../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group Driver\USB-ESL
    ../../../../../../Libraries/USB-ESL/Target/: USBTargetMH2101.c
    ../../../../../../Libraries/USB-ESL/: USBCoreZoffy.c USBDevice.c USBInterface.c InterfaceSetup.c InterfaceMSD.c InterfaceCDC.c InterfaceSerial.c InterfaceHID.c CircularBuffer.c
