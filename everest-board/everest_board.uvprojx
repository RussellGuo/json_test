# Keil uVision project everest_board.uvprojx, settings and files
target everst_board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: everest_board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PB_NO_STATIC_ASSERT=1 USE_STDPERIPH_DRIVER
  c include: ..\MH2101_SDK\Libraries\Device\MegaHunt\mhscpu\Include;..\MH2101_SDK\Libraries\MHSCPU_Driver\inc;..\host-mcu-common\include;..\mcu-driver\include;..\mcu-services\include;.\;..\..\nanopb;..\nanopb_intermediate
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group application
    ./: main.c
  group mcu_driver
    ../mcu-driver/source/: mcu-hw-common.c uart_io_API.c
    ../mcu-driver/include/: mcu-hw-common.h
  group host-mcu-protocol
    ../host-mcu-common/source/: serial_datagram.c
    ../host-mcu-common/include/: serial_datagram.h
  group host-mcu-api
    ../host-mcu-common/include/: mcu-crc32-soft.h uart_io_API.h
  group nanopb_intermediate
    ../nanopb_intermediate/: remote_message.pb.c semantic_api.generated.c semantic_api.c
  group nanopb_common
    ../../nanopb/: pb_common.c pb_decode.c pb_encode.c
  group mh2101-sdk
    ../MH2101_SDK/Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_uart.c misc.c
    ../MH2101_SDK/Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    ../MH2101_SDK/Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3
