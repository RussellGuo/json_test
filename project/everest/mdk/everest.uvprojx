# Keil uVision project everest.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: everest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\MH2101_SDK\Libraries\Device\MegaHunt\mhscpu\Include;.\..\usr;..\..\..\MH2101_SDK\Libraries\MHSCPU_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group usr
    ../usr/: main.c uart.c
  group startup
    ../../../MH2101_SDK/Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group cmsis
    ../../../MH2101_SDK/Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group sdk
    ../../../MH2101_SDK/Libraries/MHSCPU_Driver/src/: misc.c mhscpu_uart.c mhscpu_sysctrl.c mhscpu_gpio.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3
