# Keil uVision project saip_board.uvprojx, settings and files
target saip_board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: saip_board +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HXTAL_VALUE=12000000,IS_MCU_SIDE=1
  c include: ..\host-mcu-common\include;..\mcu-driver\include;..\mcu-services\include
  asm define: VERSION_DATE=0x20210120,FW_VERSION=0x0100
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ./: main.c task_serial_datagram_recv.h task_serial_datagram_recv.c
  group mcu-driver
    ../mcu-driver/include/: mcu-hw-common.h i2c-base.h t-sensor.h eeprom.h
    ../mcu-driver/source/: mcu-hw-common.c uart_io_API.c i2c-base.c t-sensor.c eeprom.c
  group host-mcu-protocol
    ../host-mcu-common/include/: serial_datagram.h semantic_api.h
    ../host-mcu-common/source/: serial_datagram.c semantic_api.c
  group host-mcu-api
    ../host-mcu-common/include/: mcu-crc32-soft.h uart_io_api.h misc.h mcu-led-mode.h mcu-laser-mode.h mcu-flashlight-mode.h mcu-camera-mode.h mcu-connectivity-test-result.h run_info_result_desc.h
  group mcu-services
    ../mcu-services/include/: service_led.h service_laser.h mcu-common.h service_flashlight.h
    ../mcu-services/source/: service_led.c service_laser.c service_flashlight.c service_set_mcu_log_level.c service_get_fw_version.c service_get_run_info.c
  group mcu-services-hw
    ../mcu-services-hw/: service_flashlight_hw.c service_laser_hw.c service_led_hw.c service_connectivity_test_hw.c service_save_psn_into_eeprom_hw.c service_camera_hw.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:GD32E10x_StdPeripherals:EXTI 1.0.3, Device:GD32E10x_StdPeripherals:FMC 1.0.3, Device:GD32E10x_StdPeripherals:GPIO 1.0.3, Device:GD32E10x_StdPeripherals:I2C 1.0.3, Device:GD32E10x_StdPeripherals:MISC 1.0.3, Device:GD32E10x_StdPeripherals:PMU 1.0.3, Device:GD32E10x_StdPeripherals:RCU 1.0.3, Device:GD32E10x_StdPeripherals:TIMER 1.0.3, Device:GD32E10x_StdPeripherals:USART 1.0.3, Device:GD32E10x_libopt 1.0.3, Device:Startup 1.0.3
