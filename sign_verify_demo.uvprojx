# Keil uVision project sign_verify_demo.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: sign_verify_demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac5.sct
  group Source Files
    ./src/: main.c sign_verify.c sign_verify.h firmware_sign_verify.c firmware_sign_verify.h firmware_layout_constant.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.3, Security:mbed Crypto 3.0.1
