# Keil uVision project start_board.uvprojx, settings and files
target start_board (6140001::V6.14.1::ARMCLANG)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: start_board
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32E103R_START
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ./: main.c task_led_blink.h task_led_blink.c user_key_isr.c user_key_isr.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:GD32E10x_StdPeripherals:EXTI 1.0.3, Device:GD32E10x_StdPeripherals:FMC 1.0.3, Device:GD32E10x_StdPeripherals:GPIO 1.0.3, Device:GD32E10x_StdPeripherals:I2C 1.0.3, Device:GD32E10x_StdPeripherals:MISC 1.0.3, Device:GD32E10x_StdPeripherals:PMU 1.0.3, Device:GD32E10x_StdPeripherals:RCU 1.0.3, Device:GD32E10x_StdPeripherals:TIMER 1.0.3, Device:GD32E10x_StdPeripherals:USART 1.0.3, Device:GD32E10x_libopt 1.0.3, Device:Startup 1.0.3
